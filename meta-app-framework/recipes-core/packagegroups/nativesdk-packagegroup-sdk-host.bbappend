RDEPENDS_${PN} =+ "nativesdk-af-main-tools"


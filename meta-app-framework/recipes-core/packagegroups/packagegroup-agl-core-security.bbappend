RDEPENDS_${PN} += "\
	xmlsec1 \
	cynara \
	dbus-cynara \
	security-manager \
	security-manager-policy \
	agl-users \
    "


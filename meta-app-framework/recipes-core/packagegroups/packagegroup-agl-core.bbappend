RDEPENDS_${PN} += "\
   packagegroup-agl-app-framework \
   "

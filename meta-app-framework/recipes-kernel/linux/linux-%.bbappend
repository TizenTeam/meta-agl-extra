FILESEXTRAPATHS_prepend := "${THISDIR}/linux:"
SRC_URI_append_smack = " file://audit.cfg"


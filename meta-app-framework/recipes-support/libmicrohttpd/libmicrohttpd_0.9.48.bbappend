
FILESEXTRAPATHS_append := ":${THISDIR}/${PN}"
SRC_URI += " file://allows-upgrade.patch"


